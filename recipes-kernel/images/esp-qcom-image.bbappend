#Enable read only rootfs
KERNEL_CMDLINE_EXTRA:append = " ro"
