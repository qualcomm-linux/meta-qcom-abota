#Enable read only rootfs
IMAGE_FEATURES += " read-only-rootfs "

