#Enable read only rootfs
IMAGE_FEATURES += " read-only-rootfs "
QCOM_PARTITION_FILES_SUBDIR:qcs8300-ride-sx = "partitions/qcs8300-ride-sx/emmc"
